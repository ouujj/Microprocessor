ORG	0000H
JMP	START

ORG	0100H
START:	CLR	C
ORL	P1,#0FH
ANL	P1,#0FH	
MOV	DPTR,#XTABLE

UP:	SETB	P1.7
	CLR	P1.4
	CALL	LOOPUP	
	JNB	P1.0,DOWN
	JMP	UP
	
DOWN:	SETB	P1.4
	CLR	P1.7
	CALL	LOOPDOWN
	JNB	P1.3,UP
	JMP	DOWN	

LOOPUP:	MOV	A,R7
INC	A
MOV	B,#10
DIV	AB
MOV	A,B
MOV	R7,A
MOVC	A,@A+DPTR
MOV	P3,A
CALL	DLY00
JMP	UP

LOOPDOWN:	MOV	A,R7
DEC	A
MOV	B,#10
DIV	AB
MOV	A,B
MOV	R7,A
MOVC	A,@A+DPTR
MOV	P3,A
CALL	DLY00
JMP	DOWN

XTABLE:	DB	3FH,06H,5BH,4FH
	DB	66H,6DH,7DH,07H
	DB	7FH,6FH

DLY00:	MOV	R0,#10
_DLY00:	DJNZ	Acc,_DLY00
DJNZ	B,_DLY00
DJNZ	R0,_DLY00
RET



END