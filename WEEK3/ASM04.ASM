	ORG 	0000H
	
	;START
	MOV	DPTR,#1020H
	MOVX	A,@DPTR
	MOV 	R0,A
	MOV	DPTR,#1021H
	MOVX	A,@DPTR
	MOV 	R1,A
	
	;STOP
	MOV	DPTR,#1030H
	MOVX	A,@DPTR
	MOV 	R2,A
	MOV	DPTR,#1031H
	MOVX	A,@DPTR
	MOV 	R3,A
	
	MOV	A,R2
	MOV	DPH,A
	MOV	A,R3
	MOV	DPL,A
	INC	DPTR
	MOV	A,DPH
	MOV	R2,A
	MOV	A,DPL
	MOV	R3,A
	
	
	;DESTINATION
	MOV	DPTR,#1040H
	MOVX	A,@DPTR
	MOV 	R4,A
	MOV	DPTR,#1041H
	MOVX	A,@DPTR
	MOV 	R5,A
	
LOOP:	MOV	A,R0
	MOV	DPH,A
	MOV	A,R1
	MOV	DPL,A
	
	MOVX	A,@DPTR
	MOV	R7,A	;SAVE AT R7 FROM DPTR
	INC	DPTR	;SHIF
	;SAVE NEW ADDR
	MOV     A,DPH	
	MOV	R0,A
	MOV     A,DPL
	MOV	R1,A
	
	MOV	A,R4
	MOV	DPH,A
	MOV	A,R5
	MOV	DPL,A
	
	MOV 	A,R7
	MOVX	@DPTR,A
	INC	DPTR
	MOV     A,DPH	
	MOV	R4,A
	MOV     A,DPL
	MOV	R5,A
	
	MOV	A,R0
	MOV	B,A
	MOV	A,R2
	
	CJNE	A,B,LOOP
	MOV	A,R1
	MOV	B,A
	MOV	A,R3
	CJNE	A,B,LOOP
	
	SJMP 	$
	
	END